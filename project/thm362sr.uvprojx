# Keil uVision project thm362sr.uvprojx, settings and files
target thm362 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: thm362sr
  group src
    ./: main.c libsr.a libsr.h sr_test.h
  group system
    ./GCC/: gcc_arm.ld startup_ARMCM3.c startup_ARMCM3.S system_ARMCM3.c
