# Keil uVision project THM36-2.uvprojx, settings and files
target GCC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: THM36x2_GCC +hex
  group Startup
    ../../Startup/: startup_thm36_gcc.s
  group Hal
    ../../Drivers/HAL/src/: crc.c dma.c exti.c flash.c flash_cache.c gpio.c i2c.c iso7816M.c pwr.c rcc.c sensor.c spi.c tim.c uart.c vbat.c wdt.c pll_enable.c
  group User
    ../../User/src/: main.c system_thm36x2.c thm3662_it.c
    ../../User/inc/: config.h
  group Pxat
    ../../../Pxat/: pxat_include.h pxat_define.h pxat_cmd.c pxat_cmd.h pxat_led.c pxat_led.h pxat_uart.c pxat_uart.h pxat_var.c pxat_var.h pxat_vendor.c pxat_vendor.h libsr.a libsr.h
